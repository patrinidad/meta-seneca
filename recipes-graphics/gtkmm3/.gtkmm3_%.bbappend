# Update the license file checksum

LICENSE = "MIT"

LIC_FILES_CHKSUM = "ﬁle://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
